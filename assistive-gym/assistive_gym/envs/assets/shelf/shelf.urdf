Commit message: debug special

File: assistive-gym/assistive_gym/envs/assets/shelf/shelf.urdf (robot description, URDF)
Before this commit: robot shelf.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=.02 .25 .4; collision box size=.02 .25 .4
